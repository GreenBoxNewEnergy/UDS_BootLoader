# IAR project Project.ewp, settings and files
configuration 1_0D (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103V8 ST STM32F103V8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: ..\; ..\BSP; ..\TP; ..\CAN; ..\UDS; ..\..\..\Utilities\Dunen_Lib\UDS_V1.00; ..\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration 1_0R (ARM)
  as the first configuration, except:
  group App
    ../: app.c CRC32.c d3des.c eeprom.c flash.c stm32f10x_it.c
  group STM32_BSP
    ../BSP/: bsp.c bsp.h
    ../../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/iar/: startup_stm32f10x_md.s
    ../: system_stm32f10x.c
  group STM32_BSP/STM32F10x_StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group UDS
    ../UDS/: EncryptAlg1.c UDS_APP.c UDS_Callback.c UDS_Config.c UDS_Const.h UDS_Driver.c UDS_DSI.c UDS_RDBI.c UDS_Routine.c UDS_WDBI.c
  group UDS/stack
    ../../../Utilities/Dunen_Lib/UDS_V1.00/: UDS.c UDS_NWS.c
