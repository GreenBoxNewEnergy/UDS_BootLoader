# IAR project Backup of Project.ewp, settings and files
configuration 1_0 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: ..\; ..\BSP; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include; ..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group App
    ../: app.c BootLoader.c BootLoader.h d3des.c d3des.h stm32f10x_it.c
  group STM32_BSP
    ../BSP/: bsp.c bsp.h delay.c
    ../../../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/iar/: startup_stm32f10x_md.s
    ../: system_stm32f10x.c
  group STM32_BSP/STM32F10x_StdPeriph_Driver
    ../../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
